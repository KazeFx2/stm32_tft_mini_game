# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWLIB\inc;..\SYSTEM\usart;.;..\CMSIS\startup\arm;..\SYSTEM\gpio;.\LCD1602;.\MUSIC;.\OLED;..\SYSTEM\spi;..\SYSTEM\sys;..\SYSTEM\threads;.\C_LCD;..\SYSTEM\dma;.\KEYS;.\C_LCD_DRAW;.\DATA
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/: core_cm3.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dac.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ./LCD1602/: lcd1602.c
    ./OLED/: oled.c
    ./MUSIC/: music.c
    ./C_LCD/: c_lcd.c c_lcdfont.c
    ./KEYS/: keys.c
    ./C_LCD_DRAW/: c_lcd_draw.c
    ./DATA/: pics.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/gpio/: gpio.c
    ../SYSTEM/spi/: spi.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/threads/: threads.c
    ../SYSTEM/dma/: dma.c
  group STARTUP
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
